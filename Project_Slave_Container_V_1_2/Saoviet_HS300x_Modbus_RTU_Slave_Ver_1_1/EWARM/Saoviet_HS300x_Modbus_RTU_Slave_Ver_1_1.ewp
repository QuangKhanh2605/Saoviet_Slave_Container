# IAR project Saoviet_HS300x_Modbus_RTU_Slave_Ver_1_1.ewp, settings and files
configuration Saoviet_HS300x_Modbus_RTU_Slave_Ver_1_1 (ARM, debug)
  General.OGChipSelectEditMenu: STM32L031F6 ST STM32L031F6
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L031xx
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32L0xx_HAL_Driver/Inc; ../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32L0xx/Include; ../Drivers/CMSIS/Include; ..\user_app_temp_humi; ..\user_hs300x; ..\user_modbus_rtu; ..\user_uart
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Saoviet_HS300x_Modbus_RTU_Slave_Ver_1_1.hex
  ILINK.IlinkOutputFile: Saoviet_HS300x_Modbus_RTU_Slave_Ver_1_1.out
  ILINK.IlinkIcfFile: stm32l031xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l031xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32l0xx_hal_msp.c stm32l0xx_it.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_exti.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_iwdg.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c
  group user_app_temp_humi
    ../user_app_temp_humi/: user_app_temp_humi.c user_app_temp_humi.h
  group user_hs300x
    ../user_hs300x/: HS300x.c HS300x.h
  group user_modbus_rtu
    ../user_modbus_rtu/: user_modbus_rtu.c user_modbus_rtu.h
  group user_uart
    ../user_uart/: user_uart.c user_uart.h
