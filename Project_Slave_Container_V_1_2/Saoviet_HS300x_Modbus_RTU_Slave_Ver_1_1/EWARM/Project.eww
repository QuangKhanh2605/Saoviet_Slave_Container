<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Saoviet_HS300x_Modbus_RTU_Slave_Ver_1_1.ewp</path>
  </project>
  <batchBuild />
</workspace>
