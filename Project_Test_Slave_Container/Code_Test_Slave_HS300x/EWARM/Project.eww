<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Code_Test_Slave_HS300x.ewp</path>
  </project>
  <batchBuild />
</workspace>
