# IAR project Code_Test_Slave_HS300x.ewp, settings and files
configuration Code_Test_Slave_HS300x (ARM, debug)
  General.OGChipSelectEditMenu: STM32L151RC ST STM32L151RC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L151xC
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32L1xx_HAL_Driver/Inc; ../Drivers/STM32L1xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32L1xx/Include; ../Drivers/CMSIS/Include; ..\user_modbus_rtu; ..\user_uart; ..\user_util; ..\user_app_test_slave_hs300x; ..\user_eventdriven
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Code_Test_Slave_HS300x.hex
  ILINK.IlinkOutputFile: Code_Test_Slave_HS300x.out
  ILINK.IlinkIcfFile: stm32l151xc_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l151xc.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c usart.c stm32l1xx_it.c stm32l1xx_hal_msp.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l1xx.c
  group Drivers/STM32L1xx_HAL_Driver
    ../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_uart.c stm32l1xx_hal.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_dma.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_cortex.c stm32l1xx_hal_exti.c
  group user_app_test_slave_hs300x
    ../user_app_test_slave_hs300x/: user_app_test_slave_hs300x.c user_app_test_slave_hs300x.h
  group user_eventdriven
    ../user_eventdriven/: event_driven.c event_driven.h
  group user_modbus_rtu
    ../user_modbus_rtu/: user_modbus_rtu.c user_modbus_rtu.h
  group user_uart
    ../user_uart/: user_uart.c user_uart.h
  group user_util
    ../user_util/: user_util.c user_util.h
